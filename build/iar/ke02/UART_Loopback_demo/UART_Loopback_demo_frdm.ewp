# IAR project UART_Loopback_demo_frdm.ewp, settings and files
configuration FLASH_32KB_PFLASH (ARM, debug)
  General.OGChipSelectEditMenu: MKE02Z64xxx2 Freescale MKE02Z64xxx2
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: IAR; FRDM_KE02; CPU_KE02
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\CMSIS\Include; ..\..\..\..\src\projects\ke02\UART_Loopback_demo; ..\..\..\..\src\common; ..\..\..\..\src\cpu; ..\..\..\..\src\cpu\headers; ..\..\..\..\src\drivers\acmp; ..\..\..\..\src\drivers\adc; ..\..\..\..\src\drivers\bme; ..\..\..\..\src\drivers\crc; ..\..\..\..\src\drivers\ftm; ..\..\..\..\src\drivers\gpio; ..\..\..\..\src\drivers\ics; ..\..\..\..\src\drivers\iic; ..\..\..\..\src\drivers\kbi; ..\..\..\..\src\drivers\nvm; ..\..\..\..\src\drivers\pit; ..\..\..\..\src\drivers\pmc; ..\..\..\..\src\drivers\rtc; ..\..\..\..\src\drivers\sim; ..\..\..\..\src\drivers\spi; ..\..\..\..\src\drivers\uart; ..\..\..\..\src\drivers\wdog; ..\..\..\..\src\drivers\pwt; ..\..\..\..\src\drivers\can; ..\..\..\..\src\platforms; ..\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: UART_Loopback_demo_frdm.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\config files\KE0x_Flash_32K.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH_64KB_PFLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\config files\KE0x_Flash_64K.icf
  group common
    ../../../../src/common/: alloc.c assert.c assert.h common.h io.c io.h memtest.c memtest.h printf.c queue.c queue.h startup.c startup.h stdlib.c stdlib.h typedef.h uif.c uif.h
  group cpu
    ../../../../src/cpu/: arm_cm0.c arm_cm0.h crt0.s start.c start.h sysinit.c sysinit.h systick.c systick.h vectors.c vectors.h
  group cpu/headers
    ../../../../src/cpu/headers/: MKE02Z2.h
  group drivers/ACMP
    ../../../../src/drivers/acmp/: acmp.c acmp.h
  group drivers/ADC
    ../../../../src/drivers/adc/: adc.c adc.h
  group drivers/BME
    ../../../../src/drivers/bme/: BME.h
  group drivers/CRC
    ../../../../src/drivers/crc/: crc.c crc.h
  group drivers/FTM
    ../../../../src/drivers/ftm/: ftm.c ftm.h
  group drivers/GPIO
    ../../../../src/drivers/gpio/: gpio.c gpio.h
  group drivers/ICS
    ../../../../src/drivers/ics/: ics.c ics.h
  group drivers/IIC
    ../../../../src/drivers/iic/: i2c.c i2c.h
  group drivers/KBI
    ../../../../src/drivers/kbi/: kbi.c kbi.h
  group drivers/NVM
    ../../../../src/drivers/nvm/: flash.c flash.h
  group drivers/PIT
    ../../../../src/drivers/pit/: pit.c pit.h
  group drivers/PMC
    ../../../../src/drivers/PMC/: pmc.c pmc.h
  group drivers/RTC
    ../../../../src/drivers/rtc/: rtc.c rtc.h
  group drivers/SIM
    ../../../../src/drivers/sim/: sim.c sim.h
  group drivers/SPI
    ../../../../src/drivers/spi/: spi.c spi.h
  group drivers/UART
    ../../../../src/drivers/uart/: uart.c uart.h
  group drivers/WDOG
    ../../../../src/drivers/wdog/: wdog.c wdog.h
  group IAR
    ../config files/: KE0x_Flash_32K.icf KE0x_Flash_64K.icf KE0x_Flash_64K_bootloaderApp.icf KE0x_Flash_64K_EEPROM_256.icf KE0x_Flash_64K_FlashConfig.icf KE0x_RAM_4KB.icf
  group levaux_layer
    ../../../../../ke02_cpp_drv/inc/: Adc.h Eeprom.h Exti.h Gpio.h Pwm.h TimerBase.h TimerMcs.h TimerMcs100.h TimerMs.h Uart.h WatchDog.h
    ../../../../../ke02_cpp_drv/src/: Adc_impl.cpp Eeprom_impl.cpp Exti_impl.cpp Gpio_impl.cpp Pwm_impl.cpp TimerBase_impl.cpp TimerMcs100_impl.cpp TimerMcs_impl.cpp TimerMs_impl.cpp Uart_impl.cpp Watchdog_impl.cpp
  group platforms
    ../../../../src/platforms/: ke02_config.h
  group project
    ../../../../src/projects/KE02/UART_Loopback_demo/: isr.h UART_app.c UART_app.h UART_Loopback_demo.c
